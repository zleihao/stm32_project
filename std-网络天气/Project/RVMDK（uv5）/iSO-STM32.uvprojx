# Keil uVision project iSO-STM32.uvprojx, settings and files
target WF-ESP8266 (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\gpio;..\..\User\SysTick;..\..\User\usart;..\..\User\Common;..\..\User\ESP8266;..\..\User\dwt_delay;..\..\User\key;..\..\User\delay;..\..\User\sys;..\..\User\SysTick;..\..\User\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/gpio/: bsp_gpio.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/Common/: Common.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/usart/: bsp_usart.c
    ../../User/ESP8266/: bsp_esp8266.c bsp_esp8266_test.c
    ../../User/key/: bsp_key.c
    ../../User/delay/: Systick.c
    ../../User/sys/: sys.c
    ../../User/OLED/: oled.c
